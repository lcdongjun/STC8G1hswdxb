# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: test
  c flags: Optimize=8 SizeSpeed=1
  c include: .\main;.\Lib
  group Source Group 1
    ./: STARTUP.A51
    ./main/: main.c
  group Lib
    ./Lib/: Config.h isr.asm STC8G_H_Delay.c STC8G_H_Delay.h STC8G_H_Compare.c STC8G_H_Compare.h STC8G_H_Compare_Isr.c STC8G_H_Exti.c STC8G_H_Exti.h STC8G_H_Exti_Isr.c STC8G_H_GPIO.c STC8G_H_GPIO.h STC8G_H_GPIO_Isr.c STC8G_H_NVIC.c STC8G_H_NVIC.h STC8G_H_Timer.c STC8G_H_Timer.h STC8G_H_Timer_Isr.c STC8G_H_UART.c STC8G_H_UART.h STC8G_H_UART_Isr.c STC8G_PCA.c STC8G_PCA.h STC8G_PCA_Isr.c Type_def.h
