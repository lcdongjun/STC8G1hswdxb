# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\main;.\system;.\bsp\1838;.\bsp\ds18b20;.\bsp\eeprom
  group Source Group 1
    ./: STARTUP.A51
    ./main/: main.c
    ./system/: uart.c uart.h config.h delay.c delay.h
  group bsp
    ./bsp/1838/: IRM.c IRM.h
    ./bsp/ds18b20/: ds18b20.c ds18b20.h
    ./bsp/eeprom/: eeprom.c eeprom.h
